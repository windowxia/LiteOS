# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOS_LPC54114 DEBUG, CPU_LPC54114J256BD64_cm4 LOS_KERNEL_TEST_SYSTICK LOS_KERNEL_DEBUG_OUT
  c misc: --library_interface=armcc --diag_suppress=66,1296,186
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\example\include;..\..\platform\LPC54110_BOARD;..\..\platform\LPC54110_BOARD\devices\LPC54114;..\..\platform\LPC54110_BOARD\devices\LPC54114\drivers;..\..\platform\LPC54110_BOARD\devices\LPC54114\utilities;..\..\platform\LPC54110_BOARD\board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\..\platform\LPC54110_BOARD\LPC54114J256_cm4.scf
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/LPC54114J256
    ../../platform/LPC54110_BOARD/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/LPC54110_BOARD/: los_startup_keil.s
    ../../platform/LPC54110_BOARD/devices/LPC54114/arm/: startup_LPC54114_cm4.s
  group user
    ../../user/: main.c
  group device/lpc54114
    ../../platform/LPC54110_BOARD/devices/LPC54114/: system_LPC54114_cm4.c
  group device/lpc54114/drivers
    ../../platform/LPC54110_BOARD/devices/LPC54114/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
  group device/lpc54114/utilities
    ../../platform/LPC54110_BOARD/devices/LPC54114/utilities/: fsl_debug_console.c
  group device/lpc54114/board
    ../../platform/LPC54110_BOARD/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group device/lpc54114/lib
    ../../platform/LPC54110_BOARD/devices/LPC54114/arm/: keil_lib_power.lib
